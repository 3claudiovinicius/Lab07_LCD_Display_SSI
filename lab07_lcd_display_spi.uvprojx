# Keil uVision project lab07_lcd_display_spi.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab07_lcd_display_spi +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: PART_TM4C1294NCPDT
  c include: C:\ti\TivaWare_C_Series-2.2.0.295\inc;C:\ti\TivaWare_C_Series-2.2.0.295;..\libraries_to_edit\ST7789-main\ST7789-main\Src;..\Lab07_LCD_Display_SSI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: main.c
  group Documentation
    ./: readme.txt
  group Libraries
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../libraries_to_edit/ST7789-main/ST7789-main/Src/: st7789.c st7789.h st7789_conf.h st7789_font.c st7789_font.h
    ./: stm32_to_tiva_SPI.c stm32_to_tiva_SPI.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
